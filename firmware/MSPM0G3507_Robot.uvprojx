# Keil uVision project MSPM0G3507_Robot.uvprojx, settings and files
target MSPM0G3507_Robot (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20100000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) XRAM(0x20200000,0x00008000) XRAM2(0x20300000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MSPM0G3507_Robot +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: .;e:\Desktop\mspm0_sdk_2_10_00_04__all\mspm0_sdk_2_10_00_04\source\third_party\CMSIS\Core\Include;e:\Desktop\mspm0_sdk_2_10_00_04__all\mspm0_sdk_2_10_00_04\source
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT6: ROM 0x20200000 size 0x8000
  memory RVCT7: ROM 0x20300000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x8000
  scatter file: .\mspm0g3507.sct
  link misc: e:\Desktop\mspm0_sdk_2_10_00_04__all\mspm0_sdk_2_10_00_04\source\ti\driverlib\lib\keil\m0p\mspm0g1x0x_g3x0x\driverlib.a
  group Source
    ./: main.c ti_msp_dl_config.c ti_msp_dl_config.h startup_mspm0g350x_uvision.s
